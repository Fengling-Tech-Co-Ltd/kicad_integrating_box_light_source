# Repository Fengling-Tech-Co-Ltd/kicad_integrating_box_light_source

File README.md:

# kicad_integrating_box_light_source

胶片翻拍用「积分盒」四色 LED 光源 —— KiCad 工程。

## 功能

- **R / G / B / IR 四个独立通道**，每通道 4 颗 3535 灯珠串联，恒流 333 mA
- 恒流驱动 **AL8862SP-13**（滞环降压，`I_OUT = 0.1 V / R_SET`），CTRL 端 0.4–2.5 V **DC（模拟）调光**
- 调光由 **MCP4728**（I2C 四路 12 位 DAC）给出，CH1–CH4 对应 R/G/B/IR
- 光强闭环：**BPW34 + OPA333 跨阻 + ADS1110**（16 位 ΔΣ ADC，同一 I2C 总线）
- 电源：24 V 输入 → 2 A 保险丝 + SMBJ30CA TVS + SS54 防反接 → **LM317 线性**产生 3V3（模拟电源用线性，避开开关噪声）

## 图纸结构（层次式）

| 图纸 | 内容 |
|---|---|
| `integrating_box_light_source.kicad_sch` | 顶层：J1(24V)、J2(I2C)、I2C 上拉、7 个层次图 |
| `power_protection.kicad_sch` | 24 V 输入防护 + LM317 3V3 |
| `led_cc_driver.kicad_sch` / `_g` / `_b` / `_ir` | 四路恒流驱动（红/绿/蓝/红外） |
| `dac_with_external_vref.kicad_sch` | MCP4728 四路 DAC |
| `light_sensor.kicad_sch` | 光强检测前端 |

每张图内都有中文的 **参数计算**、**LAYOUT 要点**（引用器件手册原文），红通道图上嵌有 AL8862 数据手册裁出的 SO-8EP 推荐焊盘图。

## 关键计算

| 项目 | 值 | 依据 |
|---|---|---|
| LED 电流（100%） | 333 mA | `I_OUT = 0.1 V / R_SET`，R_SET = R30 |
| 电感 | 100 µH | `t_OFF = L·ΔI/(V_LED+V_D+I·(R_SET+R_L))`；满载 570–700 kHz（手册推荐 33–100 µH，高压取大） |
| 输入电容 | 10 µF/50V | 手册推荐 4.7–10 µF，X7R |
| 3V3 | 3.28 V | `1.25×(1+390/240)`，TO-252，耗散 0.19 W |
| 跨阻增益 | 47 kΩ ∥ 10 pF | 带宽 339 kHz，噪声 ≈20 µV rms，折算 1.33 nA/LSB |

## 灯珠与立创编号

| 通道 | 位号 | 型号 | 立创编号 |
|---|---|---|---|
| 红 | LED_R1–R4 | XL-HD3535SURC-A2 | C3646952 |
| 绿 | LED_G1–G4 | JNJ-LEHG0113W120 | C19185875 |
| 蓝 | LED_B1–B4 | XL-HD3535UBC-A2 | C3646953 |
| 红外 | LED_IR1–IR4 | XL-HD3535HIR-T4A2 | C5221244 |
| 驱动 IC | U4–U7 | AL8862SP-13 | C526360 |

灯珠立创编号写在符号的 `LCSC Part` 字段里，`BOM_立创编号.csv` 由 KiCad 网表导出生成，可直接用于下单核对。

## 打开方式

KiCad 10 打开 `integrating_box_light_source.kicad_pro`。工程自带两个库表：
- `sym-lib-table` → `LCSC.kicad_sym`（AL8862 符号）
- `fp-lib-table` → `integrating_box_light_source.pretty`（自建 3535 灯珠封装）

## 状态

- 原理图：整机 ERC **0 error / 0 warning**
- PCB：已建板，布局进行中
- 尚未完成：其余阻容/连接器的立创编号待补齐

## KiCad design integrating_box_light_source.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2
J1: Conn_01x02_焊线焊盘; PinHeader_1x02_P2.54mm_Vertical
J2: Conn_01x03_焊线焊盘; PinHeader_1x03_P2.54mm_Vertical
J3, J4: FPC_0.5mm_4P_卧贴; HC-FPC-05-09-4RLTAG; LCSC C5213746
JP1, JP2, JP3, JP4: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
R9, R10: 4k7; R_0603_1608Metric
TP1, TP2, TP3, TP4, TP5, TP6: TestPoint; TestPoint_Loop_D2.50mm_Drill1.85mm

Connections:
+3V3: J3.4, J4.1, R9.1, R10.1, TP5.1 (1_1); also elsewhere on the board
/CH1: JP1.1 (A), TP1.1 (1_1); also elsewhere on the board
/CH2: JP2.1 (A), TP2.1 (1_1); also elsewhere on the board
/CH3: JP3.1 (A), TP3.1 (1_1); also elsewhere on the board
/CH4: JP4.1 (A), TP4.1 (1_1); also elsewhere on the board
/DAC_with_external_Vref/CH1: JP1.2 (B); also elsewhere on the board
/DAC_with_external_Vref/CH2: JP2.2 (B); also elsewhere on the board
/DAC_with_external_Vref/CH3: JP3.2 (B); also elsewhere on the board
/DAC_with_external_Vref/CH4: JP4.2 (B); also elsewhere on the board
/Light_Sensor/SCL: J3.2; also elsewhere on the board
/Light_Sensor/SDA: J3.3; also elsewhere on the board
/SCL: J2.2, J4.3, R10.2; also elsewhere on the board
/SDA: J2.1, J4.2, R9.2; also elsewhere on the board
GND: J1.2, J2.3, J3.1, J4.4, TP6.1 (1_1); also elsewhere on the board
VCOM: J1.1; also elsewhere on the board

Notes on the sheet:
模拟电路，需严格恪守数据手册中的LAYOUT规范
对外接口，连接到外部单片机
MASTER BOARD
对外接口，连接到外部24V供电
R/G/B/IR四通道LED光源，配合外部结构，构成胶片翻拍积分盒 设计要点： 1. R/G/B/IR灯珠的发光频率需与胶片色罩频率匹配 2. 各通道需保持小的亮度差异，避免出现整体色偏 3. 温度将会影响电流源基准和LED灯珠工作电流及频率 4. 可以加光强传感器做闭环控制
SLAVE BOARD
I2C上拉电阻
通过FPC线连接到J3
通过FPC线连接到J4
生产时必须使用铝基板以加强散热

Parts:
C3: 10u/50V; C_1206_3216Metric
D16: SS34; D_SMB
L3: 100uH; L_1210_3225Metric
LED_B1, LED_B2, LED_B3, LED_B4: XL-HD3535UBC-A2; LED_3535_3500x3500mm; LCSC Part C3646953
R3: R30; R_1206_3216Metric
U6: AL8862SP-13; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm; MPN AL8862SP-13; LCSC Part C526360

Connections:
+24V: C3.1, D16.1 (K), R3.1, U6.4 (VIN); also elsewhere on the board
/CH3: U6.8 (CTRL); also elsewhere on the board
GND: C3.2, U6.2 (GND), U6.7 (GND), U6.9 (EP); also elsewhere on the board
unnamed: D16.2 (A), L3.1, U6.5 (SW), U6.6 (SW)
unnamed: LED_B1.2 (A), LED_B3.1 (K)
unnamed: L3.2, LED_B1.1 (K)
unnamed: LED_B2.2 (A), R3.2, U6.1 (SET)
unnamed: LED_B2.1 (K), LED_B4.2 (A)
unnamed: LED_B3.2 (A), LED_B4.1 (K)

Notes on the sheet:
【参数计算 — 蓝通道 · DC 调光】 调光方式：CTRL 加 0.4~2.5 V 直流（analog / DC dimming），不是 PWM I_LED(100%) = 0.1/0.30 = 333 mA；ΔI = 26 mV/R_SET = 86.6 mA（VSET_HYS = ±13%，固定值） V_LED = 4×3.4 V = 13.6 V（蓝光 Vf 最高，留给恒流源余量最小） t_OFF = 100µ×86.6m/(13.6+0.5+0.13) = 610 ns t_ON = 8.66µ/(24−13.6−0.13) = 845 ns → f_SW = 687 kHz（满载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
【原理】AL8862 滞环降压：VIN → R_SET → LED 串 → L → SW；开关关断时 D17(SW→VIN) 续流 【LAYOUT】SW→L/D 走线最短以降低 EMI；EP 大面积铺铜 + 散热过孔；R_SET 与 VIN/SET 用 Kelvin 接法 【焊接】3535 灯珠回流焊 240±5℃/6s，只建议返修时手工焊（<300℃/3s）

Parts:
C12: 100n; C_0603_1608Metric
C13: 1u; C_0603_1608Metric
U3: MCP4728; MSOP-10_3x3mm_P0.5mm

Connections:
+3V3: C12.1, C13.1, U3.1 (VDD); also elsewhere on the board
/DAC_with_external_Vref/CH1: U3.6 (VOUTA); also elsewhere on the board
/DAC_with_external_Vref/CH2: U3.7 (VOUTB); also elsewhere on the board
/DAC_with_external_Vref/CH3: U3.8 (VOUTC); also elsewhere on the board
/DAC_with_external_Vref/CH4: U3.9 (VOUTD); also elsewhere on the board
/SCL: U3.2 (SCL); also elsewhere on the board
/SDA: U3.3 (SDA); also elsewhere on the board
GND: C12.2, C13.2, U3.4 (~LDAC), U3.10 (VSS); also elsewhere on the board

Notes on the sheet:
【说明】MCP4728 无外部基准引脚，基准取自 VDD(+3V3)：4 通道共用同一基准 → 通道间比例误差最小； 满量程 0~3.3 V，覆盖 AL8862 CTRL 的 0.4~2.5 V 全调光段。（若必须外部基准，可改 DAC7574） 【LAYOUT】VDD 的 100nF 紧靠引脚 1 并直接回地；I2C 短且远离 SW 节点；四路 VOUT 等长同层，避免与 SW 平行
【参数计算 — 调光链路与 I2C】 调光性质：MCP4728 输出直流电平 → AL8862 CTRL，属 DC（模拟）调光，非 PWM LSB = VDD/4096 = 3.3/4096 = 0.806 mV CTRL 0.4 V→10%、2.5 V→100% ⇒ 代码 497→3102（2605 级覆盖 10~100%，约 0.035%/级） （对照：PWM 调光需 CTRL 在 <0.3 V 与 >2.6 V 间切换，本设计不用） I2C 上拉：Rp,max = tr/(0.847·Cb)；400 kHz 时 tr ≤ 300 ns，板内 Cb≈50 pF ⇒ Rp ≤ 7 kΩ 现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

Parts:
C7: 10u/50V; C_1206_3216Metric
C8, C11: 100n; C_0603_1608Metric
C9: 1u/50V; C_0805_2012Metric
C10: 10u/16V; C_0805_2012Metric
D22: SMBJ30CA; D_SMB
D24: SS54; D_SMB
F1: 2A/125V; Fuse_1206_3216Metric
R6: 240; R_0603_1608Metric
R7: 390; R_0603_1608Metric
R8: 470; R_0603_1608Metric
U10: LM317; TO-252-2

Connections:
+3V3: C10.1, C11.1, R6.1, R8.1, U10.2 (VO); also elsewhere on the board
+24V: C7.1, C8.1, C9.1, D24.1 (K), U10.3 (VI); also elsewhere on the board
GND: C7.2, C8.2, C9.2, C10.2, C11.2, D22.1 (A1), R7.2, R8.2; also elsewhere on the board
unnamed: D22.2 (A2), D24.2 (A), F1.2
unnamed: R6.2, R7.1, U10.1 (ADJ)
VCOM: F1.1; also elsewhere on the board

Notes on the sheet:
【24V 输入与防护】 J1(24V) → F1 2A 保险丝 → D22 SMBJ30CA 抑制浪涌 → D24 SS54 肖特基防反接 → +24V 母线 反接时 D24 截止，后级不受损；C7/C8 为母线储能与高频旁路 保险丝：4×333 mA = 1.33 A ⇒ 2A；TVS：SMBJ30CA 关断 30 V > 24×1.1 = 26.4 V，峰值钳位 48.4 V
【LM317 计算】 VOUT = 1.25V × (1 + R7/R6) = 1.25 × (1 + 390/240) = 3.28 V 压差 24−3.3 = 20.7 V，负载 ≈ 9.1 mA → P = 20.7 × 9.1m = 0.19 W（TO-252 免散热片） R8 = 470Ω 预负载（7 mA），保证 LM317 轻载稳压；C9 输处、C10/C11 输出

Parts:
C14: 10p; C_0603_1608Metric
C15, C16: 100n; C_0603_1608Metric
D1: BPW34S-SMD; Osram_BPW34S-SMD; LCSC Part C145262
R11: 47k; R_0603_1608Metric
U1: ADS1110; SOT-23-6
U2: OPA333xxDBV; SOT-23-5

Connections:
+3V3: C15.1, C16.1, U1.5 (VDD), U2.5 (V+); also elsewhere on the board
/Light_Sensor/SCL: U1.3 (SCL); also elsewhere on the board
/Light_Sensor/SDA: U1.4 (SDA); also elsewhere on the board
GND: C15.2, C16.2, D1.1 (K), U1.2 (GND), U1.6 (VIN-), U2.2 (V-), U2.3 (+); also elsewhere on the board
unnamed: C14.2, D1.2 (A), R11.2, U2.4 (-)
unnamed: C14.1, R11.1, U1.1 (VIN+), U2.1

Notes on the sheet:
【LAYOUT】跨阻输入节点面积最小；Rf 紧靠反相输入，输入走线加保护环并保持助焊剂清洗干净 OPA333：避免热电偶效应（Avoid temperature gradients that create thermoelectric (Seebeck) effects） ——远离热源、避免异种金属结点、防止气流直吹 ADS1110：差分输入成对走线、远离 SW 节点与电感；VDD 的 100nF 就近回地
【参数计算 — 跨阻前端与 ADC】 V_OUT = I_ph × Rf = I_ph × 47k（BPW34 灵敏度典型 0.6 A/W） 例：10 µA → 0.47 V；50 µA → 2.35 V（ADS1110 满量程 ±2.048 V @PGA=1） 带宽 f_p = 1/(2π·Rf·Cf) = 1/(2π×47k×10p) = 339 kHz（Cf 兼作相位补偿） 噪声：√(4kTRf) = 28 nV/√Hz，折合总噪声 ≈ 20 µV rms（约 0.3 LSB） ADC 分辨率：LSB = 4.096/65536 = 62.5 µV ⇒ 电流分辨率 62.5µ/47k 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

Parts:
C2: 10u/50V; C_1206_3216Metric
D11: SS34; D_SMB
L2: 100uH; L_1210_3225Metric
LED_G1, LED_G2, LED_G3, LED_G4: JNJ-LEHG0113W120; LED_3535_3500x3500mm; LCSC Part C19185875
R2: R30; R_1206_3216Metric
U5: AL8862SP-13; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm; MPN AL8862SP-13; LCSC Part C526360

Connections:
+24V: C2.1, D11.1 (K), R2.1, U5.4 (VIN); also elsewhere on the board
/CH2: U5.8 (CTRL); also elsewhere on the board
GND: C2.2, U5.2 (GND), U5.7 (GND), U5.9 (EP); also elsewhere on the board
unnamed: D11.2 (A), L2.1, U5.5 (SW), U5.6 (SW)
unnamed: LED_G1.2 (A), LED_G3.1 (K)
unnamed: L2.2, LED_G1.1 (K)
unnamed: LED_G2.2 (A), R2.2, U5.1 (SET)
unnamed: LED_G2.1 (K), LED_G4.2 (A)
unnamed: LED_G3.2 (A), LED_G4.1 (K)

Notes on the sheet:
【参数计算 — 绿通道 · DC 调光】 调光方式：CTRL 加 0.4~2.5 V 直流（analog / DC dimming），不是 PWM I_LED(100%) = 0.1/0.30 = 333 mA；ΔI = 26 mV/R_SET = 86.6 mA（VSET_HYS = ±13%，固定值） V_LED = 4×3.2 V = 12.8 V（Vf 2.8~3.5 V，取典型 3.2） t_OFF = 100µ×86.6m/(12.8+0.5+0.13) = 650 ns t_ON = 8.66µ/(24−12.8−0.13) = 783 ns → f_SW = 698 kHz（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
【原理】AL8862 滞环降压：VIN → R_SET → LED 串 → L → SW；开关关断时 D17(SW→VIN) 续流 【LAYOUT】SW→L/D 走线最短以降低 EMI；EP 大面积铺铜 + 散热过孔；R_SET 与 VIN/SET 用 Kelvin 接法 【焊接】3535 灯珠回流焊 240±5℃/6s，只建议返修时手工焊（<300℃/3s）

Parts:
C4: 10u/50V; C_1206_3216Metric
D21: SS34; D_SMB
L4: 100uH; L_1210_3225Metric
LED_IR1, LED_IR2, LED_IR3, LED_IR4: XL-HD3535HIR-T4A2; LED_3535_3500x3500mm; LCSC Part C5221244
R4: R30; R_1206_3216Metric
U7: AL8862SP-13; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm; MPN AL8862SP-13; LCSC Part C526360

Connections:
+24V: C4.1, D21.1 (K), R4.1, U7.4 (VIN); also elsewhere on the board
/CH4: U7.8 (CTRL); also elsewhere on the board
GND: C4.2, U7.2 (GND), U7.7 (GND), U7.9 (EP); also elsewhere on the board
unnamed: D21.2 (A), L4.1, U7.5 (SW), U7.6 (SW)
unnamed: LED_IR1.2 (A), LED_IR3.1 (K)
unnamed: L4.2, LED_IR1.1 (K)
unnamed: LED_IR2.2 (A), R4.2, U7.1 (SET)
unnamed: LED_IR2.1 (K), LED_IR4.2 (A)
unnamed: LED_IR3.2 (A), LED_IR4.1 (K)

Notes on the sheet:
【参数计算 — 红外通道 · DC 调光】 调光方式：CTRL 加 0.4~2.5 V 直流（analog / DC dimming），不是 PWM I_LED(100%) = 0.1/0.30 = 333 mA；ΔI = 26 mV/R_SET = 86.6 mA（VSET_HYS = ±13%，固定值） V_LED = 4×1.55 V = 6.2 V t_OFF = 100µ×86.6m/(6.2+0.5+0.13) = 1268 ns t_ON = 8.66µ/(24−6.2−0.13) = 487 ns → f_SW = 570 kHz（满载 CCM） 红外灯珠 Vf 温漂较大（约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
【原理】AL8862 滞环降压：VIN → R_SET → LED 串 → L → SW；开关关断时 D17(SW→VIN) 续流 【LAYOUT】SW→L/D 走线最短以降低 EMI；EP 大面积铺铜 + 散热过孔；R_SET 与 VIN/SET 用 Kelvin 接法 【焊接】3535 灯珠回流焊 240±5℃/6s，只建议返修时手工焊（<300℃/3s）

Parts:
C1: 10u/50V; C_1206_3216Metric
D6: SS34; D_SMB
L1: 100uH; L_1210_3225Metric
LED_R1, LED_R2, LED_R3, LED_R4: XL-HD3535SURC-A2; LED_3535_3500x3500mm; LCSC Part C3646952
R1: R30; R_1206_3216Metric
U4: AL8862SP-13; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm_ThermalVias; MPN AL8862SP-13; LCSC Part C526360

Connections:
+24V: C1.1, D6.1 (K), R1.1, U4.4 (VIN); also elsewhere on the board
/CH1: U4.8 (CTRL); also elsewhere on the board
GND: C1.2, U4.2 (GND), U4.7 (GND), U4.9 (EP); also elsewhere on the board
unnamed: D6.2 (A), L1.1, U4.5 (SW), U4.6 (SW)
unnamed: LED_R1.2 (A), LED_R3.1 (K)
unnamed: L1.2, LED_R1.1 (K)
unnamed: LED_R2.2 (A), R1.2, U4.1 (SET)
unnamed: LED_R2.1 (K), LED_R4.2 (A)
unnamed: LED_R3.2 (A), LED_R4.1 (K)

Notes on the sheet:
【原理】AL8862 滞环降压：VIN → R_SET → LED 串 → L → SW；开关关断时 D17(SW→VIN) 续流 【LAYOUT】SW→L/D 走线最短以降低 EMI；EP 大面积铺铜 + 散热过孔；R_SET 与 VIN/SET 用 Kelvin 接法 【焊接】3535 灯珠回流焊 240±5℃/6s，只建议返修时手工焊（<300℃/3s）
【参数计算 — 红通道 · DC 调光】 调光方式：CTRL 加 0.4~2.5 V 直流（analog / DC dimming），不是 PWM I_LED(100%) = 0.1/R_SET = 0.1/0.30 = 333 mA（V_SET 典型 100 mV） ΔI = 26 mV/R_SET = 86.6 mA —— 固定值（手册 VSET_HYS = ±13% × 100 mV），调暗时纹波不跟着变小 V_LED = 4×2.4 V = 9.6 V t_OFF = L·ΔI/(V_LED+V_D+I_LED·(R_SET+R_L)) = 100µ×86.6m/10.1 = 857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

Board: 2 copper layers, 78 parts (0 on the bottom side), 44 nets, no tracks yet.

File BOM_立创编号.csv:

Refs,Qty,Value,Footprint,LCSC Part,MPN
"C1,C2,C3,C4,C7",5,10u/50V,Capacitor_SMD:C_1206_3216Metric,(未填),10u/50V
"C8,C11,C12,C15,C16",5,100n,Capacitor_SMD:C_0603_1608Metric,(未填),100n
C9,1,1u/50V,Capacitor_SMD:C_0805_2012Metric,(未填),1u/50V
C10,1,10u/16V,Capacitor_SMD:C_0805_2012Metric,(未填),10u/16V
C13,1,1u,Capacitor_SMD:C_0603_1608Metric,(未填),1u
C14,1,10p,Capacitor_SMD:C_0603_1608Metric,(未填),10p
D1,1,BPW34S-SMD,OptoDevice:Osram_BPW34S-SMD,C145262,BPW34S-SMD
"D6,D11,D16,D21",4,SS34,Diode_SMD:D_SMB,(未填),SS34
D22,1,SMBJ30CA,Diode_SMD:D_SMB,(未填),SMBJ30CA
D24,1,SS54,Diode_SMD:D_SMB,(未填),SS54
F1,1,2A/125V,Fuse:Fuse_1206_3216Metric,(未填),2A/125V
"H1,H2,H3,H4",4,MountingHole,MountingHole:MountingHole_2.2mm_M2,(未填),MountingHole
J1,1,Conn_01x02_焊线焊盘,Connector_Wire:SolderWire-0.5sqmm_1x02_P4.6mm_D0.9mm_OD2.1mm,(未填),Conn_01x02_焊线焊盘
J2,1,Conn_01x03_焊线焊盘,Connector_Wire:SolderWire-0.25sqmm_1x03_P4.2mm_D0.65mm_OD1.7mm,(未填),Conn_01x03_焊线焊盘
"J3,J4",2,FPC_0.5mm_4P_卧贴,integrating_box_light_source:HC-FPC-05-09-4RLTAG,C5213746,FPC_0.5mm_4P_卧贴
"L1,L2,L3,L4",4,100uH,Inductor_SMD:L_1210_3225Metric,(未填),100uH
"LED_B1,LED_B2,LED_B3,LED_B4",4,XL-HD3535UBC-A2,integrating_box_light_source:LED_3535_3500x3500mm,C3646953,XL-HD3535UBC-A2
"LED_G1,LED_G2,LED_G3,LED_G4",4,JNJ-LEHG0113W120,integrating_box_light_source:LED_3535_3500x3500mm,C19185875,JNJ-LEHG0113W120
"LED_IR1,LED_IR2,LED_IR3,LED_IR4",4,XL-HD3535HIR-T4A2,integrating_box_light_source:LED_3535_3500x3500mm,C5221244,XL-HD3535HIR-T4A2
"LED_R1,LED_R2,LED_R3,LED_R4",4,XL-HD3535SURC-A2,integrating_box_light_source:LED_3535_3500x3500mm,C3646952,XL-HD3535SURC-A2
"R1,R2,R3,R4",4,R30,Resistor_SMD:R_1206_3216Metric,(未填),R30
R6,1,240,Resistor_SMD:R_0603_1608Metric,(未填),240
R7,1,390,Resistor_SMD:R_0603_1608Metric,(未填),390
R8,1,470,Resistor_SMD:R_0603_1608Metric,(未填),470
"R9,R10",2,4k7,Resistor_SMD:R_0603_1608Metric,(未填),4k7
R11,1,47k,Resistor_SMD:R_0603_1608Metric,(未填),47k
U1,1,ADS1110,Package_TO_SOT_SMD:SOT-23-6,(未填),ADS1110
U2,1,OPA333xxDBV,Package_TO_SOT_SMD:SOT-23-5,(未填),OPA333xxDBV
U3,1,MCP4728,Package_SO:MSOP-10_3x3mm_P0.5mm,(未填),MCP4728
U4,1,AL8862SP-13,Package_SO:SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm_ThermalVias,C526360,AL8862SP-13
"U5,U6,U7",3,AL8862SP-13,Package_SO:SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm,C526360,AL8862SP-13
U10,1,LM317,Package_TO_SOT_SMD:TO-252-2,(未填),LM317
